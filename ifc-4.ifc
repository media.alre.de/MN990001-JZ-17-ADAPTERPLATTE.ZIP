Properties of the parts of a building model (IFC4)

# File
Description: Adapterplatte für Berlin 3000 Gehäuse (fest verdrahtet), ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MN990001, Adapterplatte für Berlin 3000 Gehäuse (fest verdrahtet)
In: Raum
Description: Adapterplatte für Berlin 3000 Gehäuse (fest verdrahtet), Kunststoff, weiß. Inklusive Befestigungsschrauben zur Montage des HTRRBu, KTBSB, ETBSB auf die Adapterplatte.; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MN990001; ModelLabel: JZ-17; GlobalTradeItemNumber: 4050528051660; ProductURL: https://alre.de/produkt_MN990001
Pset_Specification - NominalLength: 0.1053 m; NominalWidth: 0.1046 m; NominalDepth: 0.019 m; NetWeight: 0.033
Pset_ALRE_ETIM_Properties - Ausführung: Montagehilfe; Länge: 104.6; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MN990001.pdf
